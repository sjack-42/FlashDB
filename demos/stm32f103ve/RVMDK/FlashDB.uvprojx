# Keil uVision project FlashDB.uvprojx, settings and files
target FlashDB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FlashDB
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE, USE_HAL_DRIVER, SOC_SERIES_STM32F1
  c include: ..\applications;..\drivers;..\libraries\CMSIS\Include;..\libraries\CMSIS\Device\ST\STM32F1xx\Include;..\libraries\CMSIS\RTOS\Template;..\libraries\STM32F1xx_HAL_Driver\Inc;..\..\..\inc;..\..\..\port\fal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Applications
    ../applications/: main.c syscall_armlibc.c
  group Samples
    ../../../samples/: kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c tsdb_sample.c
  group FlashDB
    ../../../src/: fdb.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group FAL
    ../../../port/fal/src/: fal.c fal_flash.c fal_partition.c
    ../../../port/fal/samples/porting/: fal_flash_stm32f1_port.c
  group Drivers
    ../drivers/: board.c drv_clk.c drv_common.c drv_usart.c
  group STM32F1xx_HAL_Driver
    ../libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_flash.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_cortex.c
  group CMSIS
    ../libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
